Commit message: 3.0.17.20250710122103

File: resources/robots/PF_P441C/urdf/robot.urdf (robot description, URDF)
Before this commit: robot point_foot, 12 links, 11 joints
Joints:
- joint abad_R_Joint: origin xyz=0.039 -0.1095 -0.08725 rpy=0 0 0 -> xyz=0.039 -0.1005 -0.08725 rpy=0 0 0
